# IAR project 247-637 S-0010 V7.ewp, settings and files
configuration 247-637 S-0010 V7 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 247-637 S-0010 V7.hex
  ILINK.IlinkOutputFile: 247-637 S-0010 V7.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../Inc/: main.h
  group Application/User/INTERFACE
    ../Src/: Bouton1_Interface.c Bouton1_Interface.h Bouton_Arret_Interface.c Bouton_Arret_Interface.h Bouton_Depart_Interface.c Bouton_Depart_Interface.h Carte_Lumiere_Interface.c Carte_Lumiere_Interface.h Convoyeur_Interface.c Convoyeur_Interface.h Detecteur_Capacitif_Interface.c Detecteur_Capacitif_Interface.h Detecteur_Elevateur_Interface.c Detecteur_Elevateur_Interface.h Detecteur_Optique_Chute_Interface.c Detecteur_Optique_Chute_Interface.h Detecteur_Optique_Interface.c Detecteur_Optique_Interface.h Detecteur_Piston_Interface.c Detecteur_Piston_Interface.h Detecteur_Poussoir_Magasin_Interface.c Detecteur_Poussoir_Magasin_Interface.h Detecteur_Ventouse_Interface.c Detecteur_Ventouse_Interface.h Elevateur_Interface.c Elevateur_Interface.h interfaceMoteur.c interfaceMoteur.h interfaceS0008.c interfaceS0008.h Poussoir_Magasin_Interface.c Poussoir_Magasin_Interface.h
  group Application/User/PILOTE
    ../Src/: Carte_Lumiere_Pilote.c Carte_Lumiere_Pilote.h I2C_Pilote.c I2C_Pilote.h OB1_Pilote.c OB1_Pilote.h piloteCAN1.c piloteCAN1.h piloteIOMoteur.c piloteIOMoteur.h piloteTimer6Up.c piloteUSART2.c
  group Application/User/PROCESSUS
    ../Src/: processusAscenceur.c processusAscenceur.h processusPasserelleCan637.c processusPasserelleCan637.h
  group Application/User/SERVICE
    ../Src/: I2C_PCF_Service.c I2C_PCF_Service.h serviceBaseDeTemps.c serviceBaseDeTemps.h serviceProtocole637.c serviceProtocole637.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
